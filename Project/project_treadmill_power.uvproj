# Keil uVision project project_treadmill_power.uvproj, settings and files
target Target 1 (MCS-51)
  device: N76E003 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0x2FF) CLOCK(16000000)
  output: project_treadmill_power +hex
  c flags: SizeSpeed=1
  c define: FOSC_160000
  c include: ..\App;..\Mid;..\Driver;..\Utilities;..\Common
  group App
    ../App/: irfapp_main.c irfapp_main.h main.c main_init.c main_init.h mainfunclist.c mainfunclist.h
  group Common
    ../Common/: Function_Define.h N76E003.h SFR_Macro.h
  group Driver
    ../Driver/: adc.c adc.h delay.c delay.h pwm.c pwm.h timer.c timer.h uart.c uart.h
  group Mid
    ../Mid/: Irf.c Irf.h motor.c motor.h relay.c relay.h tick.c tick.h floor.c floor.h
  group Startup
    ../Startup/: STARTUP.A51
  group Utilitis
    ../Utilities/: queue.c queue.h xor.c xor.h
